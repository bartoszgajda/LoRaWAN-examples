# Keil uVision project transmit.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: transmit +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: CONFIG_GPIO_AS_PINRESET CFG_DEBUG CFG_eu868 CFG_sx1276_radio
  c include: ../../lmic;..\..\nRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: main.c
  group lmic
    ../../lmic/: aes.c hal.h lmic.c lmic.h lorabase.h oslmic.c oslmic.h radio.c
  group nRF52_hal
    ../../nRF52/: debug.c debug.h hal.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.1
